# Keil uVision project EE447_project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EE447_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: asm_input.s button.c button.h control.c control.h init heat_cool.c init heat_cool.h input_asm.c input_asm.h LED.c LED.h main.c Nokia5110.c Nokia5110.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
